# Keil uVision project SmartPhone.uvprojx, settings and files
target TM4C129 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1290NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SmartPhone
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\SmartPhone;.\App;.\App\inc;.\App\src;.\Drivers;.\Drivers\inc;.\Drivers\src;.\Periphs;.\Periphs\inc;.\Periphs\src;.\API;.\API\lvgl;.\API\lvgl\src;.\API\lvgl\lv_core;.\API\lvgl\lv_draw;.\API\lvgl\lv_font;.\API\lvgl\lv_hal;.\API\lvgl\lv_misc;.\API\lvgl\lv_objx;.\API\lvgl\lv_themes
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group App/src
    ./App/src/: main.c Fifo.c
  group Drivers/src
    ./Drivers/src/: TouchScreen.c HX8357.c SIM800H.c PCF8523.c
  group Periphs/src
    ./Periphs/src/: SSI0.c PLL.c ADC0.c ADC1.c UART0.c UART2.c SysTick.c Timer0A.c
  group API
    ./API/: lv_conf.h
  group API/lvgl
    ./API/lvgl/: lvgl.h
  group API/lvgl/src
    ./API/lvgl/src/: lv_version.h lv_conf_checker.h
  group API/lvgl/src/lv_core
    ./API/lvgl/src/lv_core/: lv_debug.c lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_style.c lv_refr.c lv_debug.h lv_disp.h lv_group.h lv_indev.h lv_obj.h lv_style.h lv_refr.h
  group API/lvgl/src/lv_draw
    ./API/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_triangle.c lv_draw_rect.c lv_img_cache.c lv_img_decoder.c lv_draw.h lv_draw_arc.h lv_draw_basic.h lv_draw_img.h lv_draw_label.h lv_draw_line.h lv_draw_rect.h lv_draw_triangle.h lv_img_cache.h lv_img_decoder.h
  group API/lvgl/src/lv_font
    ./API/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c lv_font.h lv_font_fmt_txt.h lv_symbol_def.h
  group API/lvgl/src/lv_hal
    ./API/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c lv_hal.h lv_hal_disp.h lv_hal_indev.h lv_hal_tick.h
  group API/lvgl/src/lv_misc
    ./API/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_utils.c lv_anim.h lv_area.h lv_async.h lv_bidi.h lv_circ.h lv_color.h lv_fs.h lv_gc.h lv_ll.h lv_log.h lv_math.h lv_mem.h lv_printf.h lv_task.h lv_templ.h lv_txt.h lv_types.h lv_utils.h
  group API/lvgl/src/lv_objx
    ./API/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_cpicker.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c lv_arc.h lv_bar.h lv_btn.h lv_btnm.h lv_calendar.h lv_canvas.h lv_cb.h lv_chart.h lv_cont.h lv_cpicker.h lv_ddlist.h lv_gauge.h lv_img.h lv_imgbtn.h lv_kb.h lv_label.h lv_led.h lv_line.h lv_list.h lv_lmeter.h lv_mbox.h lv_objx_templ.h lv_page.h lv_preload.h lv_roller.h lv_slider.h lv_spinbox.h lv_sw.h lv_ta.h lv_table.h lv_tabview.h lv_tileview.h lv_win.h
  group API/lvgl/src/lv_themes
    ./API/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c lv_theme.h lv_theme_alien.h lv_theme_default.h lv_theme_material.h lv_theme_mono.h lv_theme_nemo.h lv_theme_night.h lv_theme_templ.h lv_theme_zen.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
